Commit message: support ros_openpi env, ready to merge openpi pipline, test complated

File: ROS2/X5_ws/src/arx_x5_ros2/arx_x5_controller/x5_2025.urdf (robot description, URDF)
Before this commit: robot ultron_v1.1_aa, 7 links, 6 joints
Links:
- link link6: mass 0.670 -> 0.650
